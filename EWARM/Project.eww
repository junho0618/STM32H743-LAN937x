<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADAS_LAN937x.ewp</path>
  </project>
  <batchBuild />
</workspace>
